# Keil uVision project exp4.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C1292NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: exp2_2
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C1294NCPDT
  c include: .\driverlib;.\inc;..\EXP2_2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: tm1638.c exp4_1.c PCF8591.h
  group New Group
    ./driverlib/rvmdk/: driverlib.lib
software components: Device:Startup 1.0.0
